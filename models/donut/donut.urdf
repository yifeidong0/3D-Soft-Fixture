Commit message: structured and cleaned

File: models/donut/donut.urdf (robot description, URDF)
Before this commit: robot donut, 2 links, 1 joints
Links:
- removed link arm_link1
Joints:
- removed joint joint1
