Commit message: 3-link fish added

File: models/snap-lock/snap-lock.urdf (robot description, URDF)
Before this commit: robot lock, 2 links, 1 joints
Joints:
- joint joint1: limit lower=-1.5 upper=1.5 effort=20 velocity=0.2 -> lower=-0.8 upper=0 effort=20 velocity=0.2
